# Repository botanicfields/KiCad-Template-M5Stack-FDM-Bottom

File README.md:

# KiCad-Template-M5Stack-FDM-Bottom
a PCB template of FDM-bottoms of M5Stack with footprints for KiCad.
## for KiCad 6
https://github.com/botanicfields/KiCad6-Environment

## for KiCad 5
- FDM: Fused Deposition Modeling
- Manufacture with a thickness of 1.0 mm.
- M-BUS pin numbers match pin headers and pin sockets in the KiCad library.

## KiCad design bf-021b/bf-021b.kicad_pcb

Board: 2 copper layers, 9 parts (0 on the bottom side), 2 nets.

Parts:
H1, H2, H3, H4: MountingHole; BF@MountingHole_3.2mm_M3
H5, H6, H7, H8: MountingHole; BF@MountingHole_2.2mm_M2
J1: M-BUS; BF@M5Stack_MBUS_Bottom

Connections:
GND: J1.2, J1.4, J1.6
VBUS: J1.26, J1.28, J1.30

Notices in the files:
bf-021b/bf-021b.kicad_pcb:
Copyright 2022 BotanicFields, Inc.
